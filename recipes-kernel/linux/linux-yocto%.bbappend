COMPATIBLE_MACHINE:lpi-cm = "lpi-cm"


FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
